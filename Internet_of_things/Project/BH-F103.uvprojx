# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Internet_of_things +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\DHT11;..\User\Systick;..\User\usart;..\User\BH1750;..\User\SGP30;..\User\System;..\User\Encoder;..\User\PWM;..\User\Driver;..\User\Timer;..\User\PID_Control;..\User\HWT_Gyroscope;..\User\Vector_algorithm;..\User\date_scop;..\User\Track;..\User\PS2;..\User\jetson_nano_io
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/DHT11/: DHT11.c
    ../User/Systick/: Systick.c
    ../User/usart/: usart.c
    ../User/BH1750/: BH1750.c
    ../User/SGP30/: SGP30.c
    ../User/System/: System.c
    ../User/Encoder/: Encoder.c
    ../User/PWM/: PWM.c
    ../User/Driver/: Driver.c
    ../User/Timer/: Timer.c
    ../User/PID_Control/: PID_Control.c
    ../User/HWT_Gyroscope/: HWT_Gyroscope.c
    ../User/Vector_algorithm/: Vector_algorithm.c
    ../User/date_scop/: ANO_DT.c
    ../User/Track/: Track.c
    ../User/PS2/: pstwo.c
    ../User/jetson_nano_io/: jetson_nano_io.c
  group DOC
    ../Doc/: readme.txt
